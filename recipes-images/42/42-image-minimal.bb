require 42-image.inc

SUMMARY = "42 image minimal."